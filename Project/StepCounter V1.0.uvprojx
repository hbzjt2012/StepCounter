# Keil uVision project StepCounter V1.0.uvprojx, settings and files
target StepCounter V1.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: StepCounter V1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F3X0,GD32F350
  c include: ..\Include;..\User;..\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_gd32f3x0.s
  group CMSIS
    ../Libraries/CMSIS/: system_gd32f3x0.c
  group USER
    ../User/: gd32f3x0_it.c main.c systick.c
  group DOC
    ../Doc/: readme.txt
  group FWLIB
    ../Libraries/FWlib/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group DRIVERS
    ../Drivers/: led.c usart1.c oled.c delay.c l3g4200d.c StepCount.c bh1750.c rtc.c key.c
software components: CMSIS:CORE 5.0.2
